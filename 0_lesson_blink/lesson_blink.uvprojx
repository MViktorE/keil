# Keil uVision project lesson_blink.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson_blink
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c main.h
  group CMSIS
    ./CMSIS/: cmsis_armclang.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h startup_stm32f103xb.s stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h
