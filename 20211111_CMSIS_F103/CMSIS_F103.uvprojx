# Keil uVision project CMSIS_F103.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_F103
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\core\inc;.\core\scr;.\user_libs
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ./core/inc/: main.h
  group src
    ./core/scr/: main.c
  group CMSIS
    ./CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h startup_stm32f103xb.s stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h cmsis_armclang.h
  group user_libs
    ./user_libs/: systick_cmsis_m3_mve_v0.c systick_cmsis_m3_mve_v0.h gpio_cmsis_m3_mve_v0.c gpio_cmsis_m3_mve_v0.h rcc_cmsis_m3_mve_v0.c rcc_cmsis_m3_mve_v0.h uart_cmsis_m3_mve_v0.c uart_cmsis_m3_mve_v0.h line_recognition_ciam_mve_v0.c line_recognition_ciam_mve_v0.h can_cmsis_m3_mve_v0.c can_cmsis_m3_mve_v0.h nextion_cmsis_mve_v1.c nextion_cmsis_mve_v1.h
